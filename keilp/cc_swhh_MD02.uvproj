# Keil uVision project cc_swhh_MD02.uvproj, settings and files
target SHC16L (MCS-251)
  device: Flip80251 Hurricane Dolphin
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: cc_swhh_MD02 +hex
  group app
    ../source/app/: main.c app_fsk.c app_voicecom.c app_flow.c app_action.c
  group cpu
    ../source/cpu/: START251.A51 cpu.c SHC6601_system.c
  group bsp
    ../source/bsp/: bsp_led.c msa300.c cw63xx.c
  group clib
    ../source/clib/: clib.c
  group ctask
    ../source/ctask/: task.c tick.c
  group msp
    ../source/msp/: time.c uart0.c SHC6601_rtc.c msp_buzz.c msp_rtc.c msp_adc.c msp_I2C.c SHC6601_i2c.c msp_io.c
  group debug
    ../source/debug/: debug_drv.c debug_led.c
    ../source/debug/ini/: debug_md02.ini
  group uartcom
    ../source/uartcom/: urec2protocol.c uprotocol2app.c
